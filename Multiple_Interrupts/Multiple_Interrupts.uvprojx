# Keil uVision project Multiple_Interrupts.uvprojx, settings and files
target stm32f4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F410RBIx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Multiple_Interrupts
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
