# Keil uVision project blinky.uvprojx, settings and files
target stm32f4 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F410RBIx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
